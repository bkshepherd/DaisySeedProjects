# Repository bkshepherd/DaisySeedProjects

File README.md:

# Daisy Seed Projects
This is a demo of a pedal board I put together using 3 of my custom Daisy Seed based guitar pedals. I designed and built the hardware and programmed the software. Everything shown here is open source and all the code, pcb files, and basic instructions on how to build the pedals, can be found on these pages.

## Software Projects:
### 1. [Guitar Multi-Effect Pedal](Software/GuitarPedal/README.md)
The software that can run on any of the custom Guitar Pedal hardware projects listed below as well at the PedalPCB Terrarium hardware.  This software is a flexible platform that abstracts the underlying Guitar Pedal hardware and allows a collection of Effects Modules to run on any of those hardware platforms.

## Hardware Projects:

I provide everything you need to build any of pedals you see below along with pretty detailed documentation.  However, recently I started to get a lot of requests to buy kits or finished pedals based on my designs. This is not something I typically do, but sometimes I do have extra PCBs, parts, and enclosures lying around and I'm willing to pass them along to you, basically at cost. I've included some ordering details along with each design below.

### 1. [Guitar Effect Pedal in 125b Enclosure](Hardware/GuitarPedal125b/README.md) (SMD Parts)
A feature rich and flexible platform for making DSP based guitar FX pedals. Stereo Audio, Midi in/out, OLED Display, Rotary Encoder for Menu Navigation, 6 Knobs, 2 LEDs, 2 Foot Switches, Relay based "True Bypass" switching, all based on the Daisy Seed microcontroller.

[Ordering Information](Hardware/GuitarPedal125b/docs/OrderingHardware.md)

### 2. [Guitar Effect Pedal in 1590b Enclosure](Hardware/GuitarPedal1590b-SMD/README.md) (SMD Parts)

A robust and tiny platform for making DSP based guitar FX pedals. Stereo Audio, Midi in/out, 4 Knobs, 2 LEDs, 1 or 2 Foot Switches, Relay based "True Bypass" switching, all based on the Daisy Seed microcontroller. Using SMD parts for easy manufacturing by a fab such as JLCPCB.

[Ordering Information](Hardware/GuitarPedal1590b-SMD/docs/OrderingHardware.md)

### 3. [Guitar Effect Pedal in 1590b Enclosure](Hardware/GuitarPedal1590b/README.md) (Through-hole parts)

Same form factor and features as the SMD version of the 1590b pedal, minus the Relay based "True Bypass" switching. Using all Through-Hole parts for easy assembly at home with limited soldering skills.

[Ordering Information](Hardware/GuitarPedal1590b/docs/OrderingHardware.md)

More Information about the Daisy Seed can be found at:

http://electro-smith.com

## KiCad design Hardware/GuitarPedal125b/pcb/DaisySeedPedal125b.kicad_pcb

File Hardware/GuitarPedal125b/README.md:

# Guitar Pedal 125b

### Rev 6 - 3/17/2024

Updates include:
1. Removed the PDS1 DC-DC Isolator from the power supply design.  This part was quite expensive and hard to source and wasn't really doing anything valuable to help with the noise profile of the device (especially if you are using a good pedal board power source with isolated power).  This simplifies the power supply a bit.  
2. Added a simple RC Low Pass filter immediately following the Daisy Seed audio outputs to help get rid of out of band noise caused by the Rev7 Daisy Seed.
3. Updated a bunch of components to have footprints oriented the way JLCPCB expects them.  This reduces the need to "fix" the rotation of components when having JCLPCB manufacture the PCBs.
4. Updated the design to include the 20pin headers for the Daisy Seed so that JLCPCB could also assemble these parts.  Saves a lot of time from having to solder 40 points on the PCB.
5. Updated the design to use more commonly available and cheaper Alpha brand 9mm Pots.
6. Included exported Gerber and Assembly files to make it easy to order assembled PCBs from JCLPCB. Detailed instructions can be found on the [Build the Hardware](docs/README.md) page. This requires no knowledge of KiCad to get the PCBs made and mostly Assembled.

### Overview

A project to create a digital effect pedal based on the Electro-Smith Daisy Seed that fits into a standard 125B sized Guitar Pedal enclosure. The video below shows a pedal board I made using 2 of these 125b sided pedals and demo the capabilities.

This project is an evolution of my [1590B sized Pedal](https://github.com/bkshepherd/DaisySeedProjects/tree/main/Hardware/GuitarPedal1590b).

### Features

1. 125B size pedal board friendly enclosure!
2. Buffered Stereo Input and Outputs for Guitar Level signals
2. Relay based "True Bypass" switching
3. TRS Mini MIDI Input and Outputs
4. OLED Display
5. Rotary Encoder for Display Navigation
6. 6 Pots
7. Up to 2 Footswitches
8. Up to 2 Leds
9. Standard 9v center pin negative power jack
10. Easy access to the Daisy Seed USB port and reset buttons for updating the firmware
11. Primarily SMD parts for easy assembly by your PCB provider
12. Easily order a custom drilled enclosure from Tayda! [Template Here](https://drill.taydakits.com/box-designs/new?public_key=MlRHaUhqaEVXOVVFZ1ErV1FiTXlrQT09Cg==)
13. Easily order or 3D print the enclosure using provided STEP and FreeCAD files.

This project includes a KiCad project with the necessary schematics and PCB layout files to create everything you need to build the hardware. The included exported Gerber and Assembly files make it easy to order PCBs from JCLPCB. Detailed instructions can be found on the [Build the Hardware](docs/README.md) page. This requires no knowledge of KiCad to get the PCBs made.

Once you've built the hardware you can deploy the software from my Multi-Effect Guitar Pedal software project by following these directions: [Deploy the Software to the Hardware](../../Software/GuitarPedal/README.md)

This software provides a hardware abstraction layer as well as a few custom FX including Tremolo, Chorus, Overdrive, and Stereo Auto-Pan.

## Past Updates
### Rev 5 - 6/30/2023

Updates include:
1. Updated placement of screen slightly to ease installation.
2. Updated POT footprint mounting holes to be slightly larger.
3. Properly grounded Audio TRS jacks when no cable is inserted.
4. Included exported Gerber and Assembly files to make it easy to order assembled PCBs from JCLPCB. Detailed instructions can be found on the [Build the Hardware](docs/README.md) page. This requires no knowledge of KiCad to get the PCBs made and mostly Assembled.

### Rev 4 - 5/16/2023

Updates include:
1. Updated PCB design to improve the True Bypass relay switching to include an anti-pop hardware mute.
2. Update Example Software to take advantage of the anti-pop mute.
3. Update Example Software to provide a basic menu system for the OLED Screen

### Rev 3 - 4/14/2023

Updates include:
1. Swapped the placement of the Footswitches and LEDs on the PCB to be consistent with my other pedals.

Known Issues:
1. Relay bypass has an audible pop when enabling / disabling the effect. Sounds like a common issue with relay and 3pdt switch true bypass systems.  Investigating fixing / minimizing it with an a solution similar to this [anti-pop system](https://www.coda-effects.com/2016/08/relay-bypass-with-anti-pop-system.html). Hope to add this in Rev 4.

### Rev 2 - 3/29/2023

Updates include:
1. Added 3 Additional Pots (Total of 6)
2. Improved OLED Screen Placement
3. Removed an Encoder (now just 1)
4. Tayda Custom Drill Template for easily ordering a pre-drilled enclosure

More Information about the Daisy Seed can be found at:

http://electro-smith.com

More Information about KiCad can be found at:

https://www.kicad.org

Parts:
A1: Electrosmith_Daisy_Seed_Rev7
J1: Barrel_Jack_Switch; Generic_PowerJack
J2: AUDIO_IN_TRS; NEUTRIK_NMJ6HCD2; PARTREV 26.02.2021
J3: MIDI IN JACK; PJ-320A
J4: AUDIO_OUT_TRS; NEUTRIK_NMJ6HCD2; PARTREV 26.02.2021
J5: MIDI OUT JACK; PJ-320A
J6, J7: Conn_01x20_Socket; PinSocket1x20_P2.54mm_Vertical_JLCPCB

Connections:
+3.3V: A1.38 (3V3_D), J6.3; also elsewhere on the board
+3.3VA: A1.21 (3V3_A), J6.20; also elsewhere on the board
+9V: A1.39 (VIN), J6.2; also elsewhere on the board
AUDIO_IN_BUFFER_LEFT: A1.16 (AUDIO_IN_1), J7.5; also elsewhere on the board
AUDIO_IN_BUFFER_RIGHT: A1.17 (AUDIO_IN_2), J7.4; also elsewhere on the board
AUDIO_IN_JACK_LEFT: J2.T; also elsewhere on the board
AUDIO_IN_JACK_RIGHT: J2.R; also elsewhere on the board
AUDIO_OUT_BUFFER_LEFT: A1.18 (AUDIO_OUT_1), J7.3; also elsewhere on the board
AUDIO_OUT_BUFFER_RIGHT: A1.19 (AUDIO_OUT_2), J7.2; also elsewhere on the board
AUDIO_OUT_JACK_LEFT: J4.T; also elsewhere on the board
AUDIO_OUT_JACK_RIGHT: J4.R; also elsewhere on the board
DISABLE_AUDIO_BYPASS: A1.2 (SD_DATA_3), J7.19; also elsewhere on the board
ENABLE_AUDIO_MUTE: A1.13 (I2C1_SDA), J7.8; also elsewhere on the board
ENCODER_1_A: A1.3 (SD_DATA_2), J7.18; also elsewhere on the board
ENCODER_1_B: A1.4 (SD_DATA_1), J7.17; also elsewhere on the board
ENCODER_1_CLICK: A1.5 (SD_DATA_0), J7.16; also elsewhere on the board
FOOT_SWITCH_1: A1.7 (SD_CLK), J7.14; also elsewhere on the board
FOOT_SWITCH_2: A1.6 (SD_CMD), J7.15; also elsewhere on the board
GND: A1.20 (AGND), A1.40 (DGND), J1.1, J1.3, J2.RN, J2.S, J2.SN, J2.TN, J3.S, J4.RN, J4.S, J4.SN, J4.TN, J5.S, J6.1, J7.1; also elsewhere on the board
LED_1: A1.29 (DAC_OUT2), J6.12; also elsewhere on the board
LED_2: A1.30 (DAC_OUT1), J6.11; also elsewhere on the board
MIDI_IN: A1.37 (USB_D_+), J6.4; also elsewhere on the board
MIDI_IN_JACK_PIN4: J3.R1; also elsewhere on the board
MIDI_IN_JACK_PIN5: J3.T; also elsewhere on the board
MIDI_OUT: A1.36 (USB_D_-), J6.5; also elsewhere on the board
MIDI_OUT_JACK_PIN4: J5.R1; also elsewhere on the board
MIDI_OUT_JACK_PIN5: J5.T; also elsewhere on the board
unnamed: A1.1 (USB_ID), J7.20
unnamed: A1.14 (USART1_TX), J7.7
unnamed: A1.15 (USART1_RX), J7.6
unnamed: A1.28 (ADC_6), J6.13
unnamed: A1.31 (SAI2_MCLK), J6.10
unnamed: A1.32 (SAI2_SD_B), J6.9
unnamed: A1.33 (SAI2_SD_A), J6.8
unnamed: A1.34 (SAI2_FS), J6.7
unnamed: A1.35 (SAI2_SCK), J6.6
OLED_DISPLAY_SPI_CS: A1.8 (SPI1_CS), J7.13; also elsewhere on the board
OLED_DISPLAY_SPI_DC: A1.10 (SPI1_POCI), J7.11; also elsewhere on the board
OLED_DISPLAY_SPI_MOSI: A1.11 (SPI1_PICO), J7.10; also elsewhere on the board
OLED_DISPLAY_SPI_RESET: A1.12 (I2C1_SCL), J7.9; also elsewhere on the board
OLED_DISPLAY_SPI_SCK: A1.9 (SPI1_SCK), J7.12; also elsewhere on the board
POT_1: A1.22 (ADC_0), J6.19; also elsewhere on the board
POT_2: A1.23 (ADC_1), J6.18; also elsewhere on the board
POT_3: A1.24 (ADC_2), J6.17; also elsewhere on the board
POT_4: A1.25 (ADC_3), J6.16; also elsewhere on the board
POT_5: A1.26 (ADC_4), J6.15; also elsewhere on the board
POT_6: A1.27 (ADC_5), J6.14; also elsewhere on the board
POWER_JACK_PWR: J1.2; also elsewhere on the board

Parts:
U7: OLED_DISPLAY_SSD1306_SPI; HiLetgo_OLED_SPI

Connections:
+3.3V: U7.2 (VCC); also elsewhere on the board
GND: U7.1 (GND); also elsewhere on the board
OLED_DISPLAY_SPI_CS: U7.7 (CS); also elsewhere on the board
OLED_DISPLAY_SPI_DC: U7.6 (DC); also elsewhere on the board
OLED_DISPLAY_SPI_MOSI: U7.4 (D1); also elsewhere on the board
OLED_DISPLAY_SPI_RESET: U7.5 (RES); also elsewhere on the board
OLED_DISPLAY_SPI_SCK: U7.3 (D0); also elsewhere on the board

Parts:
C5, C6: 100NF; C_0805_2012Metric
C7, C8: 10UF; C_0805_2012Metric
R1, R2, R4, R5: 2M; R_0805_2012Metric
R3, R6: 100K; R_0805_2012Metric
U2: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+5V: C5.1, C6.1, R3.1, U2.4 (V+); also elsewhere on the board
/Audio Input Buffer/V_AUDIOBIAS: R4.1, R5.1, U2.1, U2.2 (-)
AUDIO_IN_BUFFER_LEFT: U2.13 (-), U2.14; also elsewhere on the board
AUDIO_IN_BUFFER_RIGHT: U2.8, U2.9 (-); also elsewhere on the board
BYPASS_LEFT_SEND: C7.1, R1.1; also elsewhere on the board
BYPASS_RIGHT_SEND: C8.1, R2.1; also elsewhere on the board
GND: C5.2, C6.2, R1.2, R2.2, R6.2, U2.5 (+), U2.11 (V-); also elsewhere on the board
unnamed: R3.2, R6.1, U2.3 (+)
unnamed: U2.6 (-), U2.7
unnamed: C8.2, R5.2, U2.10 (+)
unnamed: C7.2, R4.2, U2.12 (+)

Parts:
C1, C4: 10UF; C_0805_2012Metric
C2, C3: 100NF; C_0805_2012Metric
D1: 1N5817; D_SOD-123
U1: LD1117S50TR_SOT223; SOT-223-3_TabPin2

Connections:
+5V: C4.1, U1.2 (VO); also elsewhere on the board
+9V: C1.1, C2.1, C3.1, D1.1 (K), U1.3 (VI); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, U1.1 (GND); also elsewhere on the board
POWER_JACK_PWR: D1.2 (A); also elsewhere on the board

Parts:
C9, C10: 2.2NF; C_0805_2012Metric
C11, C12, C15, C16: 10UF; C_0805_2012Metric
C13, C14: 100NF; C_0805_2012Metric
R7, R8: 3.3K; R_0805_2012Metric
R9, R10, R11, R12, R15, R16: 2M; R_0805_2012Metric
R13, R14: 100R; R_0805_2012Metric
U3: OPA1652AID; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C13.1, C14.1, R9.1, R11.1, U3.8 (V+); also elsewhere on the board
AUDIO_OUT_BUFFER_LEFT: R7.1; also elsewhere on the board
AUDIO_OUT_BUFFER_RIGHT: R8.1; also elsewhere on the board
BYPASS_LEFT_RETURN: C15.2, R15.1; also elsewhere on the board
BYPASS_RIGHT_RETURN: C16.2, R16.1; also elsewhere on the board
GND: C9.2, C10.2, C13.2, C14.2, R10.2, R12.2, R15.2, R16.2, U3.4 (V-); also elsewhere on the board
unnamed: C10.1, C12.2, R8.2
unnamed: C9.1, C11.2, R7.2
unnamed: C15.1, R13.2
unnamed: C16.1, R14.2
unnamed: C12.1, R11.2, R12.1, U3.3 (+)
unnamed: R14.1, U3.1, U3.2 (-)
unnamed: C11.1, R9.2, R10.1, U3.5 (+)
unnamed: R13.1, U3.6 (-), U3.7

Notes on the sheet:
Simple RC Low Pass Filter at ~22kHz to remove out of band noise from Seed Rev7

Parts:
C18, C19: 10NF; C_0805_2012Metric
ENC1: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
FS1: Foot_Switch_1; PinHeader_1x02_P2.54mm_Vertical
FS2: Foot_Switch_2; PinHeader_1x02_P2.54mm_Vertical
LED1: LED_1; PinHeader_1x02_P2.54mm_Vertical
LED2: LED_2; PinHeader_1x02_P2.54mm_Vertical
POT1, POT2, POT3, POT4, POT5, POT6: 10K; Potentiometer_Bourns_PRS11R
R24, R25: 1K; R_0805_2012Metric
R26, R27, R28, R29: 10K; R_0805_2012Metric

Connections:
+3.3V: R28.1, R29.2; also elsewhere on the board
+3.3VA: POT1.3, POT2.3, POT3.3, POT4.3, POT5.3, POT6.3; also elsewhere on the board
ENCODER_1_A: C18.1, R26.1; also elsewhere on the board
ENCODER_1_B: C19.2, R27.2; also elsewhere on the board
ENCODER_1_CLICK: ENC1.S1; also elsewhere on the board
FOOT_SWITCH_1: FS1.2; also elsewhere on the board
FOOT_SWITCH_2: FS2.2; also elsewhere on the board
GND: C18.2, C19.1, ENC1.C, ENC1.S2, FS1.1, FS2.1, LED1.1 (K), LED2.1 (K), POT1.1, POT2.1, POT3.1, POT4.1, POT5.1, POT6.1; also elsewhere on the board
LED_1: R24.2; also elsewhere on the board
LED_2: R25.2; also elsewhere on the board
unnamed: ENC1.A, R26.2, R28.2
unnamed: ENC1.B, R27.1, R29.1
unnamed: LED1.2 (A), R24.1
unnamed: LED2.2 (A), R25.1
POT_1: POT1.2; also elsewhere on the board
POT_2: POT2.2; also elsewhere on the board
POT_3: POT3.2; also elsewhere on the board
POT_4: POT4.2; also elsewhere on the board
POT_5: POT5.2; also elsewhere on the board
POT_6: POT6.2; also elsewhere on the board

Parts:
C17: 100NF; C_0805_2012Metric
D2: 1N4148; D_SOD-123
R17: 220R; R_0805_2012Metric
R18: 10R; R_0805_2012Metric
R19: 33R; R_0805_2012Metric
R20: 470R; R_0805_2012Metric
U4: H11L1; SOP-6_2.54mm

Connections:
+3.3V: C17.1, R19.2, R20.1, U4.6; also elsewhere on the board
GND: C17.2, U4.5; also elsewhere on the board
MIDI_IN: R20.2, U4.4; also elsewhere on the board
MIDI_IN_JACK_PIN4: R17.1; also elsewhere on the board
MIDI_IN_JACK_PIN5: D2.2 (A), U4.2; also elsewhere on the board
MIDI_OUT: R18.2; also elsewhere on the board
MIDI_OUT_JACK_PIN4: R19.1; also elsewhere on the board
MIDI_OUT_JACK_PIN5: R18.1; also elsewhere on the board
unnamed: D2.1 (K), R17.2, U4.1

Notes on the sheet:
Based on the Midi TRS Standard for 3.3v

Parts:
D3, D4: 1N4007; D_SOD-123F
K1, K2: G6K-2; Relay_DPDT_Omron_G6K-2G-Y
Q1: SS8050; SOT-23-3
R21, R22, R23: 1K; R_0805_2012Metric
U5, U6: CPC1018N; SOP-4_3.8x4.1mm_P2.54mm

Connections:
+5V: D3.1 (K), D4.1 (K), K1.1, K2.1; also elsewhere on the board
AUDIO_IN_JACK_LEFT: K1.4, K1.7; also elsewhere on the board
AUDIO_IN_JACK_RIGHT: K2.4, K2.7; also elsewhere on the board
AUDIO_OUT_JACK_LEFT: K1.6, U5.4; also elsewhere on the board
AUDIO_OUT_JACK_RIGHT: K2.6, U6.4; also elsewhere on the board
BYPASS_LEFT_RETURN: K1.5; also elsewhere on the board
BYPASS_LEFT_SEND: K1.3; also elsewhere on the board
BYPASS_RIGHT_RETURN: K2.5; also elsewhere on the board
BYPASS_RIGHT_SEND: K2.3; also elsewhere on the board
DISABLE_AUDIO_BYPASS: R21.1; also elsewhere on the board
ENABLE_AUDIO_MUTE: R22.1, R23.1; also elsewhere on the board
GND: K1.2, K2.2, Q1.2 (E), U5.2, U5.3, U6.2, U6.3; also elsewhere on the board
unnamed: D3.2 (A), D4.2 (A), K1.8, K2.8, Q1.3 (C)
unnamed: Q1.1 (B), R21.2
unnamed: R22.2, U5.1
unnamed: R23.2, U6.1

Board: 4 copper layers, 60.0 x 94.0 mm, 80 parts (12 on the bottom side), 66 nets.
