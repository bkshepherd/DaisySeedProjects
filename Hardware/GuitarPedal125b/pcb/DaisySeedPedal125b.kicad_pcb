# Repository bkshepherd/DaisySeedProjects (continued)

## KiCad design Hardware/GuitarPedal1590b/pcb/DaisySeedPedal1590b.kicad_pcb

File Hardware/GuitarPedal1590b/README.md:

# Guitar Pedal 1590b - Through-Hole Parts

### Rev 6 - 11/12/2023

Updates include:
1. Updated the PCB to have an optional bypass of the PDS1 5v Isolation circuit.

### Overview

A project to create a digital effect pedal based on the Electro-Smith Daisy Seed that fits into a standard 1590B sized Guitar Pedal enclosure. Electro-Smith sells a guitar pedal, but it's a much larger format, and I wanted something as small as possible.  The PedalPCB Terrarium was another option, but it's mono only, so I decided to build my own. This one is a smaller form factor than both, operates in Mono or Stereo, and has Midi support, so it's capable little pedal platform.

The video below shows a pedal board I made using this design, the smaller pedal on the far left, along with 2 of my [125B sized pedals](../GuitarPedal125b/README.md).

This project is the Through-Hole parts version of my 1590b pedal. All parts are through-hole components and can easily be hand soldered. There is also a version of this same pedal where all parts are SMD parts that can be assembled by a fab such as JLCPCB, if you are looking for that, please check out my [Guitar Pedal 1590b-SMD project](../GuitarPedal1590b-SMD/README.md).

### Features

1. Small 1590B pedal board friendly enclosure!
2. Buffered Stereo Input and Outputs for Guitar Level signals
3. TRS Mini MIDI Input and Outputs
4. 4 Pots
5. Up to 2 Foot Switches
6. Up to 2 Leds
7. Standard 9v center pin negative power jack
8. Easily Assembled from easily sourced through-hole parts, no SMD soldering required!
9. Easily order a custom drilled enclosure from Tayda!

This project includes a KiCad project with the necessary schematics and PCB layout files to create everything you need to build the hardware. The included exported Gerber and Assembly files make it easy to order PCBs from JCLPCB. Detailed instructions can be found on the [Build the Hardware](docs/README.md) page. This requires no knowledge of KiCad to get the PCBs made.

Once you've built the hardware you can deploy the software from my Multi-Effect Guitar Pedal software project by following these directions: [Deploy the Software to the Hardware](../../Software/GuitarPedal/README.md)

This software provides a hardware abstraction layer as well as a few custom FX including Tremolo, Chorus, Overdrive, and Stereo Auto-Pan.

## Past Revisions
### Rev 5 - 6/3/2023

Updates include:
1. Updated PCB to properly ground input / output jacks when no plug is inserted
2. Fixed a software issue causing noise from the LED.
3. Included exported Gerber files to make it easy to order PCBs from JCLPCB. Detailed instructions can be found on the [Build the Hardware](docs/README.md) page. This requires no knowledge of KiCad to get the PCBs made.
   
### Rev 4 - 4/12/2023

Updates include:
1. Updated PCB layout to move some components farther away from the edges
2. Swapped the placement of Footswitches and LEDs for consistency with my other projects 
3. Updated code to make Footswitch 1 & Led 1 enable / disabe the effect

### Rev 3 - 3/29/2023

Updates include:
1. Improved 4 Layer PCB Layout, much easier to assemble!
2. Replaced all SMD parts with through-hole alternative
3. Tayda Custom Drill Template for easily ordering a pre-drilled enclosure

More Information about the Daisy Seed can be found at:

http://electro-smith.com

More Information about KiCad can be found at:

https://www.kicad.org

Board: 4 copper layers, 54.0 x 106.0 mm, 60 parts (0 on the bottom side), 44 nets.

Parts:
A1: Electrosmith_Daisy_Seed_Rev4; Electrosmith_Daisy_Seed
C1, C4, C5, C9, C10, C11, C12, C15, C16: 10UF; C_Disc_D6.0mm_W2.5mm_P5.00mm
C2, C3, C7, C8, C13, C14: 100NF; C_Rect_L7.2mm_W3.0mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C6: 22UF; CP_Radial_D4.0mm_P2.00mm
C17: 100NF; C_Disc_D6.0mm_W2.5mm_P5.00mm
D1: 1N5817; D_DO-35_SOD27_P7.62mm_Horizontal
D2: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
FS1: Foot_Switch_1; PinHeader_1x02_P2.54mm_Vertical
FS2: Foot_Switch_2; PinHeader_1x02_P2.54mm_Vertical
J1: Barrel_Jack; Generic_PowerJack
J2: AUDIO_IN_TRS; NEUTRIK_NMJ6HCD2
J3: AUDIO_OUT_TRS; NEUTRIK_NMJ6HCD2
J4: MIDI IN JACK; TRRS-PJ-320A
J5: MIDI OUT JACK; TRRS-PJ-320A
L1: 2.2uH; L_Radial_D7.0mm_P3.00mm
LED1: LED_1; PinHeader_1x02_P2.54mm_Vertical
LED2: LED_2; PinHeader_1x02_P2.54mm_Vertical
POT1, POT2, POT3, POT4: 10K; Pot_RightAngle_LongPin_16mm
R1, R2, R4, R5, R7, R8, R9, R10, R13, R14: 2M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R6: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R11, R12: 100R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R15: 220R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R16: 33R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R17: 10R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R18: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R19, R20: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R21: DNP; R_0805_2012Metric
U1: L4931CZ50; TO-92_Inline_Wide
U2: PDS1-S5-S5-D; CONV_PDS1-S5-S5-D
U3: MCP6004; DIP-14_W7.62mm
U4: OPA2134; DIP-8_W7.62mm
U5: H11L1; DIP-6_W7.62mm

Connections:
+3.3V: A1.38 (3V3_D), C17.1, R16.2, R18.1, U5.6
+3.3VA: A1.21 (3V3_A), POT1.3, POT2.3, POT3.3, POT4.3
+5V: C4.1, L1.1, R21.1, U1.1 (VO)
+5V_ISOLATED_POWER: C6.1, C7.1, C8.1, C13.1, C14.1, R3.1, R7.1, R9.1, R21.2, U2.5 (+VO), U3.4 (V+), U4.8 (V+)
+9V: A1.39 (VIN), C1.1, C2.1, C3.1, D1.1 (K), U1.3 (VI)
/Audio Input Buffer/V_AUDIOBIAS: R4.1, R5.1, U3.6 (-), U3.7
/Power/VIN: C5.1, L1.2, U2.4 (VIN)
AUDIO_IN_BUFFER_LEFT: A1.16 (AUDIO_IN_1), U3.13 (-), U3.14
AUDIO_IN_BUFFER_RIGHT: A1.17 (AUDIO_IN_2), U3.1, U3.2 (-)
AUDIO_IN_JACK_LEFT: C9.1, J2.T, R1.1
AUDIO_IN_JACK_RIGHT: C10.1, J2.R, R2.1
AUDIO_OUT_BUFFER_LEFT: A1.18 (AUDIO_OUT_1), C11.2
AUDIO_OUT_BUFFER_RIGHT: A1.19 (AUDIO_OUT_2), C12.2
AUDIO_OUT_JACK_LEFT: C15.2, J3.T, R13.1
AUDIO_OUT_JACK_RIGHT: C16.2, J3.R, R14.1
FOOT_SWITCH_1: A1.7 (SD_CLK), FS1.2
FOOT_SWITCH_2: A1.6 (SD_CMD), FS2.2
GND: A1.20 (AGND), A1.40 (DGND), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C13.2, C14.2, C17.2, FS1.1, FS2.1, J1.1, J1.3, J2.RN, J2.S, J2.SN, J2.TN, J3.RN, J3.S, J3.SN, J3.TN, J4.S, J5.S, LED1.1 (K), LED2.1 (K), POT1.1, POT2.1, POT3.1, POT4.1, R1.2, R2.2, R6.2, R8.2, R10.2, R13.2, R14.2, U1.2 (GND), U2.1 (GND), U2.7 (0V), U3.10 (+), U3.11 (V-), U4.4 (V-), U5.5
LED_1: A1.29 (DAC_OUT2), R19.2
LED_2: A1.30 (DAC_OUT1), R20.2
MIDI_IN: A1.37 (USB_D_+), R18.2, U5.4
MIDI_IN_JACK_PIN4: J4.R1, R15.1
MIDI_IN_JACK_PIN5: D2.2 (A), J4.T, U5.2
MIDI_OUT: A1.36 (USB_D_-), R17.2
MIDI_OUT_JACK_PIN4: J5.R1, R16.1
MIDI_OUT_JACK_PIN5: J5.T, R17.1
unnamed: C15.1, R11.2
unnamed: C16.1, R12.2
unnamed: D2.1 (K), R15.2, U5.1
unnamed: LED1.2 (A), R19.1
unnamed: LED2.2 (A), R20.1
unnamed: C10.2, R5.2, U3.3 (+)
unnamed: R3.2, R6.1, U3.5 (+)
unnamed: U3.8, U3.9 (-)
unnamed: C9.2, R4.2, U3.12 (+)
unnamed: C12.1, R9.2, R10.1, U4.3 (+)
unnamed: R12.1, U4.1, U4.2 (-)
unnamed: C11.1, R7.2, R8.1, U4.5 (+)
unnamed: R11.1, U4.6 (-), U4.7
POT_1: A1.22 (ADC_0), POT1.2
POT_2: A1.23 (ADC_1), POT2.2
POT_3: A1.24 (ADC_2), POT3.2
POT_4: A1.25 (ADC_3), POT4.2
POWER_JACK_PWR: D1.2 (A), J1.2

## Code that names these connections

File GuitarPedal125b/src/guitar_pedal_125b.cpp:

#include "guitar_pedal_125b.h"

using namespace daisy;
using namespace bkshepherd;

#ifndef SAMPLE_RATE
//#define SAMPLE_RATE DSY_AUDIO_SAMPLE_RATE
#define SAMPLE_RATE 48014.f
#endif

// Hardware related defines.
// Switches
#define SWITCH_1_PIN 6         // Foot Switch 1
#define SWITCH_2_PIN 5         // Foot Switch 2

// Knobs
#define KNOB_PIN_1 15
#define KNOB_PIN_2 16
#define KNOB_PIN_3 17
#define KNOB_PIN_4 18
#define KNOB_PIN_5 19
#define KNOB_PIN_6 20

// Encoders
#define ENCODER_1_BUTTON_PIN 4
#define ENCODER_1_A_PIN 3
#define ENCODER_1_B_PIN 2

// LEDS
#define LED_1_PIN 22
#define LED_2_PIN 23

// Midi
#define MIDI_RX_PIN 30
#define MIDI_TX_PIN 29

// Display
#define DISPLAY_CS_PIN 7
#define DISPLAY_SCK_PIN 8
#define DISPLAY_DC_PIN 9
#define DISPLAY_MOSI_PIN 10
#define DISPLAY_RESET_PIN 11

void GuitarPedal125B::Init(bool boost)
{
    // Set Some numbers up for accessors.
    // Initialize the hardware.
    seed.Configure();
    seed.Init(boost);
    InitSwitches();
    InitEncoders();
    InitLeds();
    InitAnalogControls();
    InitMidi();
    SetAudioBlockSize(48);

    // Init the HW Audio Bypass
    audioBypassTrigger.Init(daisy::seed::D1, GPIO::Mode::OUTPUT);
    SetAudioBypass(true);

    // Init the HW Audio Mute
    audioMuteTrigger.Init(daisy::seed::D12, GPIO::Mode::OUTPUT);
    SetAudioMute(false);

    // Configure the Display
    MyOledDisplay::Config disp_cfg;
    disp_cfg.driver_config.transport_config.pin_config.dc    = seed.GetPin(DISPLAY_DC_PIN);
    disp_cfg.driver_config.transport_config.pin_config.reset = seed.GetPin(DISPLAY_RESET_PIN);
    display.Init(disp_cfg);
}

void GuitarPedal125B::DelayMs(size_t del)
{
    seed.DelayMs(del);
}

void GuitarPedal125B::SetHidUpdateRates()
{
    for(size_t i = 0; i < KNOB_LAST; i++)
    {
        knobs[i].SetSampleRate(AudioCallbackRate());
    }
    for(size_t i = 0; i < LED_LAST; i++)
    {
        leds[i].SetSampleRate(AudioCallbackRate());
    }
}

void GuitarPedal125B::StartAudio(AudioHandle::InterleavingAudioCallback cb)
{
    seed.StartAudio(cb);
}

void GuitarPedal125B::StartAudio(AudioHandle::AudioCallback cb)
{
    seed.StartAudio(cb);
}

void GuitarPedal125B::ChangeAudioCallback(AudioHandle::InterleavingAudioCallback cb)
{
    seed.ChangeAudioCallback(cb);
}

void GuitarPedal125B::ChangeAudioCallback(AudioHandle::AudioCallback cb)
{
    seed.ChangeAudioCallback(cb);
}

void GuitarPedal125B::StopAudio()
{
    seed.StopAudio();
}

void GuitarPedal125B::SetAudioBlockSize(size_t size)
{
    seed.SetAudioBlockSize(size);
    SetHidUpdateRates();
}

size_t GuitarPedal125B::AudioBlockSize()
{
    return seed.AudioBlockSize();
}

void GuitarPedal125B::SetAudioSampleRate(SaiHandle::Config::SampleRate samplerate)
{
    seed.SetAudioSampleRate(samplerate);
    SetHidUpdateRates();
}

float GuitarPedal125B::AudioSampleRate()
{
    return seed.AudioSampleRate();
}

float GuitarPedal125B::AudioCallbackRate()
{
    return seed.AudioCallbackRate();
}

void GuitarPedal125B::StartAdc()
{
    seed.adc.Start();
}

void GuitarPedal125B::StopAdc()
{
    seed.adc.Stop();
}

void GuitarPedal125B::ProcessAnalogControls()
{
    for(size_t i = 0; i < KNOB_LAST; i++)
    {
        knobs[i].Process();
    }
}

float GuitarPedal125B::GetKnobValue(KnobIndex k)
{
    size_t idx;
    idx = k < KNOB_LAST ? k : KNOB_1;
    return knobs[idx].Value();
}

void GuitarPedal125B::ProcessDigitalControls()
{
    for(size_t i = 0; i < SWITCH_LAST; i++)
    {
        switches[i].Debounce();
    }

    for(size_t i = 0; i < ENCODER_LAST; i++)
    {
        encoders[i].Debounce();
    }
}

void GuitarPedal125B::SetAudioBypass(bool enabled)
{
    audioBypass = enabled;
    audioBypassTrigger.Write(!audioBypass);
}

void GuitarPedal125B::SetAudioMute(bool enabled)
{
    audioMute = enabled;
    audioMuteTrigger.Write(audioMute);
}

void GuitarPedal125B::ClearLeds()
{
    for(size_t i = 0; i < LED_LAST; i++)
    {
        SetLed(static_cast<LedIndex>(i), 0.0f);
    }
}

void GuitarPedal125B::SetLed(LedIndex k, float bright)
{
    size_t idx;
    idx = k < LED_LAST ? k : LED_1;
    leds[idx].Set(bright);
}

void GuitarPedal125B::UpdateLeds()
{
    for(size_t i = 0; i < LED_LAST; i++)
    {
        leds[i].Update();
    }
}

void GuitarPedal125B::InitSwitches()
{
    uint8_t pin_numbers[SWITCH_LAST] = {
        SWITCH_1_PIN,
        SWITCH_2_PIN,
    };

    for(size_t i = 0; i < SWITCH_LAST; i++)
    {
        switches[i].Init(seed.GetPin(pin_numbers[i]));
    }
}

void GuitarPedal125B::InitEncoders()
{
    encoders[ENCODER_1].Init(seed.GetPin(ENCODER_1_A_PIN),
                            seed.GetPin(ENCODER_1_B_PIN),
                            seed.GetPin(ENCODER_1_BUTTON_PIN));

}

void GuitarPedal125B::InitLeds()
{
    uint8_t pin_numbers[LED_LAST] = {
        LED_1_PIN,
        LED_2_PIN,
    };

    for(size_t i = 0; i < LED_LAST; i++)
    {
        leds[i].Init(seed.GetPin(pin_numbers[i]), false);
    }
}

void GuitarPedal125B::InitAnalogControls()
{
    // Set order of ADCs based on CHANNEL NUMBER
    AdcChannelConfig cfg[KNOB_LAST];
    // Init with Single Pins
    cfg[KNOB_1].InitSingle(seed.GetPin(KNOB_PIN_1));
    cfg[KNOB_2].InitSingle(seed.GetPin(KNOB_PIN_2));
    cfg[KNOB_3].InitSingle(seed.GetPin(KNOB_PIN_3));
    cfg[KNOB_4].InitSingle(seed.GetPin(KNOB_PIN_4));
    cfg[KNOB_5].InitSingle(seed.GetPin(KNOB_PIN_5));
    cfg[KNOB_6].InitSingle(seed.GetPin(KNOB_PIN_6));

    seed.adc.Init(cfg, KNOB_LAST);
    // Make an array of pointers to the knob.
    for(int i = 0; i < KNOB_LAST; i++)
    {
        knobs[i].Init(seed.adc.GetPtr(i), AudioCallbackRate());
    }
}

void GuitarPedal125B::InitMidi()
{
    MidiUartHandler::Config midi_config;
    midi_config.transport_config.rx = seed.GetPin(MIDI_RX_PIN);
    midi_config.transport_config.tx = seed.GetPin(MIDI_TX_PIN);
    midi.Init(midi_config);
}

## Commit log (part)

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2024-12-31 Add log and inverse log for float scaling
2024-12-31 Move default center frequencies closer to the values at the middle point of the knob when using logarithmic
2024-12-31 Remove unused variable
2024-12-31 Remove unused sentinel values
2024-12-31 Refactors for safety and ability to use different curve for float parameters (#49)
    * Make getters const, use enums instead of ints cast to enums
    * Add getter for the valueCurve
    * Add log and inverse log for float scaling
    * Move default center frequencies closer to the values at the middle point of the knob when using logarithmic
    * Remove unused variables
    * Remove unused sentinel values
2024-12-31 Make narrow, medium, wide, parameters for the parametric EQ
2024-12-31 Minor fix to para eq param count
2025-01-04 Disable quick switching to tuner when no screen exists on the hardware
2025-01-04 Handle hardware with an alternate footswitch but no screen specially
2025-01-04 Cleanup alternate footswitch logic and use press-and-hold bypass to cycle through effects when there is no screen
2025-01-04 Properly skip the tuner when cycling through with no screen
2025-01-04 Minor comment added
2025-01-12 Initial simple gate
2025-01-12 Add a hold time parameter and add a smoothing filter
2025-01-12 Noise gate (#50)
    Noise gate with quite a few tweakable settings.
    I set the defaults to what work best for me/my setup.
    - Fast attack of 1ms
    - Hold and release both of 50ms
    - Fade time of ~100-200ms
    - And then threshold somewhere in the middle
2025-01-13 Added guitarml modules
2025-01-14 Fixed delay led, moved stft code, updated ci, readme
2025-01-14 Harmonize submodules and suggest different init command (#52)
    Was having trouble initializing submodules. The above changes works better.
2025-01-14 Small tweaks to fix warnings maybe?
2025-01-14 run clang-format on guitar_pedal, /Util/, and /Effect-Modules/
2025-01-14 Cleanup
2025-01-14 Remove unused looper copy
2025-01-15 Refactor location of dependencies now that we have so many
2025-01-15 Move wavenet code to dependencies folder
2025-01-15 Fix 2 warnings from static analysis
2025-01-15 Separate out loaded effects to their own file for easier editing
2025-01-15 Cleanup some warnings
2025-01-15 Cleanup some warnings (#54)
2025-01-15 Separate out loaded effects to a standalone file for easier editing (#53)
    * Separate out loaded effects to their own file for easier editing
2025-01-16 Increase level a bit and adjust EQ
2025-01-16 Increase level a bit and adjust EQ for NAM module (#55)
    - increase max output level a bit
    - adjust EQ
    - adjust method for disabling output temporarily
2025-01-16 revert narrowing eq bandwidth a little
    * revert narrowing eq bandwidth a little
2025-01-17 Improve feel of the gain knob
2025-01-18 Add comment
2025-01-18 Improve feel of the gain knob for NAM module (#57)
    * Improve feel of the gain knob by using essentially a log taper simulated pot
2025-01-18 Allow showing CPU on the default UI (or it can be accessed by any effect for rendering)
2025-01-18 Add some more level to the amp module and change the gain taper
2025-01-18 Add some more level to the amp module and change the gain taper (#60)
2025-01-19 Include some of the 3rd party dependencies as system to not generate warnings
2025-01-19 Allow showing CPU on the default UI (#59)
    * Allow showing CPU on the default UI (or it can be accessed by any effect for rendering)
    * Set blocksize once at initialization instead of twice to the same value
    * Include some of the 3rd party dependencies as system to not generate warnings
2025-01-19 Fix some more warnings
2025-01-19 Set vscode cpp properties file to cpp 20 to match project
2025-01-20 Add clang-format helper that I have been using to format the whole project
2025-01-20 Rename formatting file to be less confusing
2025-01-21 This is a copy paste with no functional change yet and the problem isn't apparent?
2025-01-26 Initial distortion module playing around
2025-01-26 Initial distortion module playing around (#61)
2025-01-26 Fix and increase oversampling for distortion after checking CPU
2025-01-26 Cleanup in distortion module
2025-01-26 Cleanup in distortion module for readability
2025-01-26 More distortion improvements
2025-02-04 Not sure I have the oomph in the daisy for it...
2025-02-22 Added fm synth and granular delay modules, and related utils
2025-02-22 Fixed stereo spread control
2025-02-24 Cleanup, commented out fm synth module
2025-03-05 Refactor to not have a temporary copy
2025-03-05 Remove unused include
2025-03-05 Make loaded effects a bit easier to manage (#63)
    * Make loaded effects a bit easier to manage (no renumbering)
2025-03-05 Fix clang-format ci/format.sh script and run it
2025-03-05 Move include
2025-03-13 Initial addition of IR and Drum modules, reduced Amp module for space
2025-03-14 Added more beats, time signatures, auto always on feature, fixed led tempo
2025-03-15 Added stereo through option
2025-03-15 Moved drum include, can be used as drum machine without midi keyboard
2025-03-15 Updated Fm keys module to not conflict with midi keys module
2025-03-16 Updated drum param order, reduced IR count for performance reasons
2025-04-19 Update a few dependencies to get a fixed fastmod function from DaisySP
2025-04-19 Run ./ci/format.sh
2025-05-18 Adjust GCC version (#67)
2025-05-18 Update README for latest web flasher
2025-05-18 Clarification about ARM gcc version
2025-05-19 Add check to makefile for the GCC version to make sure users don't experience issues
2025-05-23 Try moving pitch shifter to SDRAM so it can be included in the builds
2025-05-23 Add to loaded effects
2025-05-23 Increment persistent storage settings version just to be safe
2025-05-23 Don't use more memory than is needed
2025-05-23 Add include guard
2025-05-23 Move pitch shifter buffers to SDRAM and include it in the loaded effects by default (#68)
    * Moved pitch shifter to SDRAM so it can be included in the builds
    * Add pitch shifter to loaded effects
    * Increment persistent storage settings version just to be safe
2025-05-25 I dunno...vibe coding this has NOT worked out...
2025-05-26 Log cpu
2025-05-27 Add a few more NAM models
2025-05-27 Add a few NAM models (BE-100 and another JCM800) (#69)
    * Add a few more NAM models to learn the process
2025-05-27 What is happening...
2025-05-28 Getting better, too much CPU now
2025-05-28 Not enough oomph still
2025-06-19 Add sansamp BDDI to NAM module and update libdaisy
2025-06-20 Was it crashing when it would potentially initialize the effect and call selectmodel before the model weights were setup??
2025-06-20 Adjustments
2025-06-20 Give it a little more level...
2025-06-20 Add flag for debugging
2025-06-20 Move nam models to SDRAM
2025-06-21 Simplify diff
2025-06-21 Revert "Move nam models to SDRAM"
    This reverts commit 1620aa6166dcc7cf2f3c887827b6a8aa91f2315d.
2025-06-21 Move wavenet to sdram
2025-06-21 Reapply "Move nam models to SDRAM"
    This reverts commit 89337a44c2db6126a857fc6c9cd11f36da038ba7.
2025-06-22 Add level adjust
2025-06-22 Update libDaisy
2025-06-22 Add debug compiler options commented out as a reminder when using stlink
2025-06-22 Disable IR module
2025-06-23 WIP, runs, but maybe too slow?
2025-06-26 Remove duplicate models to save space
2025-06-26 Remove another duplicate
2025-06-26 Add Sansamp Bass Driver V1 Clean NAM model (#71)
    * Add sansamp BDDI to NAM module
    * Remove duplicate models to save space
2025-09-14 CloudSeed alternate button to mute input signal on wet
2025-10-26 Added 3D printable enclosure
2025-11-26 Confirmed Hardware Variant
2025-11-28 a version that builds and loads only tremolo to SDRAM; desgined to be a starting point for testing by greatly speeding up the build and deploy stages
2025-11-28 added GFX2 Library as a submodule this time, and moved it to dependencies
2025-11-29 a wrapper that properly compiles based off of claud's vibe coding, starting with a minimal build/deploy & deleted previously deleted misplaced GFX2 library
2025-12-01 Reimplement a phaser beacuse the daisysp has some crunch in it that I don't want
2025-12-01 Phase 2 tests draw functions, doesn't compile yet
2025-12-01 Free up some memory headroom
2025-12-01 Adjust loaded effects
2025-12-01 Fix LED logic
2025-12-01 Basic phaser (#75)
    * Initial phaser
    * Reimplement a phaser beacuse the daisysp has some crunch in it that I don't want
2025-12-02 Basic flanger
2025-12-02 Phase 2 wrapper tests that draws primitive functins, compiles, works 80% or so
2025-12-04 for now phase 2 complete test, diagonals, circles, and arcs are all still jagged, possibly an issue of the GFX2 drawing functions
2025-12-06 added support for a single font, which works, essentially completing phase 3
2025-12-09 update CI
2025-12-09 Comment out release portion for now
2025-12-18 Phase 1, 2 effects loaded, for debugging encoder
2025-12-21 Very Close (possibly there)
2025-12-25 Add tape modulator
2025-12-28 Add funbox hardware support for basic testing
2026-01-10 Commenting. Fix broken time modulation.
2026-01-10 Restore default values.
2026-01-10 Do not recompute waveform.
2026-01-10 Fix tape modulation freezing after extended use
    Wrap time accumulators to prevent floating-point precision loss.
    Without wrapping, t_wow_ and t_flutter_ grow indefinitely, causing
    precision issues in the Perlin noise calculations that result in
    getTapeSpeed returning constant values.
2026-02-27 Move hardware to SRAM to free up some dtcmram
2026-02-28 Move hardware memory location to free up some DTCMRAM (#83)
    * Move hardware to SRAM to free up some (a lot) DTCMRAM
2026-02-28 Basic testing
2026-03-06 Add a hash to force QSPI memory reset if persistent data structure changed. Avoids hard faults.
2026-03-06 Remove undesirable comment.
2026-03-06 Add a hash to force QSPI memory reset if persistent data structure changes (#85)
    * Add a hash to force QSPI memory reset if persistent data structure changed. Avoids hard faults.
    ---------
2026-03-07 Use param enums.
2026-03-07 Restore geq module wrong erasures
2026-03-08 Use enums for parameter indexing (#86)
    * Use param enums.
    ---------
2026-03-11 Crusher module inspired from EHX Mainframe
2026-03-11 Minimal change: remove null-checks
2026-03-11 Comment parameters
2026-03-11 Comment crusher processing
2026-03-15 Lock rate when leaving pitch tracking mode.
2026-03-17 Add check for encoder support.
2026-03-18 Add check for encoder support. (#88)
2026-05-02 Add ability to use the 6 knobs for 6 MORE parameters if you hold the alternate footswitch for 1 second
2026-05-02 Add ability to use knobs for more parameters in delay module (#89)
    * Add ability to use the 6 knobs for 6 MORE parameters if you hold the alternate footswitch for 1 second on the delay module
2026-05-03 Initial commit of tape delay
2026-05-15 Add some safety stuff
2026-05-16 Its a bit safer now..
2026-05-16 Some more refactor
2026-05-16 Adjust very quiet repeat even when on 0
2026-05-16 Dedicated tape delay module (#90)
    * Standalone tape delay module
2026-06-03 Fix formatting in midi_keys_module.cpp
2026-06-07 Initial test
2026-06-07 Refactor
2026-06-07 Add mute on model switch
2026-06-07 Remove previous NAM module to see space savings
2026-06-07 Revert "Remove previous NAM module to see space savings"
    This reverts commit 62f1305cff018714aff0b595b6eda302f7c9629a.
2026-06-07 Move NAM A2 model data out of QSPI and into sram
2026-06-07 Make more space in dtcmram
2026-06-07 Replace JCM2000 with a JCM800 from tonehunt, along with an ampeg SVT
2026-06-07 Add python script to use tonehunt A2 models
2026-06-08 Add loudness adjustment and try to move some data from DTCMRAM to SRAM
2026-06-08 Move to RAM_D2 instead of SRAM
2026-06-08 Restore disabled effects
2026-06-08 Rename
2026-06-08 Remove loudness detection and tune it manually
2026-06-08 Try moving heap
2026-06-08 Try moving heap...again
2026-06-08 Cleanup parameter changing
2026-06-08 Adjust loudness
2026-06-10 Add optional IR to nam_a2_module
2026-06-10 Use CMSIS IR from my asteroidbelt project, it works
2026-06-10 Use CMSIS IR for the full length 1024 ir_module also, remove eigen dependency
2026-06-10 Fixes
2026-06-10 Use full 1024 IR for nam module
2026-06-10 Remove dead function
2026-06-10 Remove cpu display
